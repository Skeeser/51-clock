# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c delay.c delay.h key.c key.h CTimer0.c CTimer0.h Timer1.c Timer1.h IR.c IR.h Int0.c Int0.h DS1302.h DS18B20.c DS18B20.h OneWire.c OneWire.h LCD1602.c LCD1602.h UART.c UART.h
